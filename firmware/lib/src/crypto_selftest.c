/*
 * Known-answer self-test of the crypto backend, run at every boot on the
 * target (PSA on the CryptoCell-310) and in the host tests (software
 * backend): the same vectors prove both backends agree. A failure shows the
 * self-test error pattern on the LED and the pod never transmits nor records.
 */
#include <string.h>

#include "pod/crypto.h"
#include "pod/errors.h"
#include "pod/radio.h"
#include "pod/selftest.h"

static const uint8_t ccm_key[16] = {0xc0, 0xc1, 0xc2, 0xc3, 0xc4, 0xc5, 0xc6, 0xc7,
				    0xc8, 0xc9, 0xca, 0xcb, 0xcc, 0xcd, 0xce, 0xcf};
static const uint8_t ccm_nonce[13] = {0x00, 0x00, 0x00, 0x03, 0x02, 0x01, 0x00,
				      0xa0, 0xa1, 0xa2, 0xa3, 0xa4, 0xa5};
static const uint8_t ccm_aad[8] = {0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07};
static const uint8_t ccm_pt[23] = {0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
				   0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
				   0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e};
/* RFC 3610, packet vector #1. */
static const uint8_t ccm_out[31] = {0x58, 0x8c, 0x97, 0x9a, 0x61, 0xc6, 0x63, 0xd2,
				    0xf0, 0x66, 0xd0, 0xc2, 0xc0, 0xf9, 0x89, 0x80,
				    0x6d, 0x5f, 0x6b, 0x61, 0xda, 0xc3, 0x84, 0x17,
				    0xe8, 0xd1, 0x2c, 0xfd, 0xf9, 0x26, 0xe0};

static const uint8_t nist_key[16] = {0x2b, 0x7e, 0x15, 0x16, 0x28, 0xae, 0xd2, 0xa6,
				     0xab, 0xf7, 0x15, 0x88, 0x09, 0xcf, 0x4f, 0x3c};
/* SP 800-38A F.5.1 plaintext = RFC 4493 message (64 B). */
static const uint8_t nist_msg[64] = {
	0x6b, 0xc1, 0xbe, 0xe2, 0x2e, 0x40, 0x9f, 0x96,
	0xe9, 0x3d, 0x7e, 0x11, 0x73, 0x93, 0x17, 0x2a,
	0xae, 0x2d, 0x8a, 0x57, 0x1e, 0x03, 0xac, 0x9c,
	0x9e, 0xb7, 0x6f, 0xac, 0x45, 0xaf, 0x8e, 0x51,
	0x30, 0xc8, 0x1c, 0x46, 0xa3, 0x5c, 0xe4, 0x11,
	0xe5, 0xfb, 0xc1, 0x19, 0x1a, 0x0a, 0x52, 0xef,
	0xf6, 0x9f, 0x24, 0x45, 0xdf, 0x4f, 0x9b, 0x17,
	0xad, 0x2b, 0x41, 0x7b, 0xe6, 0x6c, 0x37, 0x10,
};
/* RFC 4493 examples 2, 3 and 4 (16, 40 and 64 B): K1 and K2 paths. */
static const uint8_t cmac_16[16] = {
	0x07, 0x0a, 0x16, 0xb4, 0x6b, 0x4d, 0x41, 0x44,
	0xf7, 0x9b, 0xdd, 0x9d, 0xd0, 0x4a, 0x28, 0x7c,
};
static const uint8_t cmac_40[16] = {
	0xdf, 0xa6, 0x67, 0x47, 0xde, 0x9a, 0xe6, 0x30,
	0x30, 0xca, 0x32, 0x61, 0x14, 0x97, 0xc8, 0x27,
};
static const uint8_t cmac_64[16] = {
	0x51, 0xf0, 0xbe, 0xbf, 0x7e, 0x3b, 0x9d, 0x92,
	0xfc, 0x49, 0x74, 0x17, 0x79, 0x36, 0x3c, 0xfe,
};
/* SP 800-38A F.5.1, four blocks (counter carry across blocks). */
static const uint8_t ctr_iv[16] = {
	0xf0, 0xf1, 0xf2, 0xf3, 0xf4, 0xf5, 0xf6, 0xf7,
	0xf8, 0xf9, 0xfa, 0xfb, 0xfc, 0xfd, 0xfe, 0xff,
};
static const uint8_t ctr_out[64] = {
	0x87, 0x4d, 0x61, 0x91, 0xb6, 0x20, 0xe3, 0x26,
	0x1b, 0xef, 0x68, 0x64, 0x99, 0x0d, 0xb6, 0xce,
	0x98, 0x06, 0xf6, 0x6b, 0x79, 0x70, 0xfd, 0xff,
	0x86, 0x17, 0x18, 0x7b, 0xb9, 0xff, 0xfd, 0xff,
	0x5a, 0xe4, 0xdf, 0x3e, 0xdb, 0xd5, 0xd3, 0x5e,
	0x5b, 0x4f, 0x09, 0x02, 0x0d, 0xb0, 0x3e, 0xab,
	0x1e, 0x03, 0x1d, 0xda, 0x2f, 0xbe, 0x03, 0xd1,
	0x79, 0x21, 0x70, 0xa0, 0xf3, 0x00, 0x9c, 0xee,
};
/* RFC 5869 test case 3 (empty salt and info), first 16 B. */
static const uint8_t hkdf_out[16] = {0x8d, 0xa4, 0xe7, 0x75, 0xa5, 0x63, 0xc1, 0x8f,
				     0x71, 0x5f, 0x80, 0x2a, 0x06, 0x3c, 0x5a, 0x31};
/* packages/pod-protocol fixtures/v1/vectors.json, uplink "slot_request". */
static const uint8_t link_key[16] = {0x6f, 0x96, 0xc8, 0x31, 0xea, 0xbe, 0x81, 0x4d,
				     0x45, 0x7f, 0xd5, 0x3b, 0x18, 0xbb, 0x25, 0x8c};
static const uint8_t slot_request[14] = {0x13, 0x51, 0x0a, 0x17, 0x00, 0x02, 0x71,
					 0x11, 0x00, 0x00, 0x4b, 0xbc, 0x39, 0x49};

int pod_crypto_selftest(void)
{
	uint8_t buf[64];
	uint8_t ikm[22];
	struct pod_uplink_counters c = {
		.network_id = 2641,
		.pod_short_id = 23,
		.key_id = 2,
		.boot_counter = 70001,
		.frame_number = 0,
	};

	if (pod_aes128_ccm_seal(ccm_key, ccm_nonce, ccm_aad, 8, ccm_pt, 23, buf, 8) != POD_OK ||
	    memcmp(buf, ccm_out, 31) != 0) {
		return POD_SELFTEST_CCM;
	}
	if (pod_aes128_ccm_open(ccm_key, ccm_nonce, ccm_aad, 8, ccm_out, 31, buf, 8) != POD_OK ||
	    memcmp(buf, ccm_pt, 23) != 0) {
		return POD_SELFTEST_CCM;
	}
	if (pod_aes128_cmac(nist_key, nist_msg, 16, buf) != POD_OK ||
	    memcmp(buf, cmac_16, 16) != 0 || pod_aes128_cmac(nist_key, nist_msg, 40, buf) != POD_OK ||
	    memcmp(buf, cmac_40, 16) != 0 || pod_aes128_cmac(nist_key, nist_msg, 64, buf) != POD_OK ||
	    memcmp(buf, cmac_64, 16) != 0) {
		return POD_SELFTEST_CMAC;
	}
	if (pod_aes128_ctr(nist_key, ctr_iv, nist_msg, buf, 64) != POD_OK ||
	    memcmp(buf, ctr_out, 64) != 0) {
		return POD_SELFTEST_CTR;
	}
	memset(ikm, 0x0b, sizeof(ikm));
	if (pod_hkdf_sha256(ikm, sizeof(ikm), NULL, 0, buf, 16) != POD_OK ||
	    memcmp(buf, hkdf_out, 16) != 0) {
		return POD_SELFTEST_HKDF;
	}
	if (pod_uplink_seal(link_key, &c, NULL, false, buf, sizeof(buf)) != 14 ||
	    memcmp(buf, slot_request, 14) != 0) {
		return POD_SELFTEST_UPLINK;
	}
	return POD_OK;
}
